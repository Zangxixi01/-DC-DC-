# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\HARDWARE\ENCOTER;..\HARDWARE\PID;..\HARDWARE\BEEP;..\HARDWARE\SW;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\DHT11;..\HARDWARE\SD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../HARDWARE/scr/: sys.c delay.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/SD/: sd.c
    ../HARDWARE/SW/: sw.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/scr/: adc.c oled.c show.c timer2.c
    ../HARDWARE/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
  group Readme
    ../Readme/: readme.txt
